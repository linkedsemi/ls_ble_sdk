# Keil uVision project timer_test.uvprojx, settings and files
target ARMCM0 (ARM-ADS)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.6.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: timer_test
  AfterMake: ..\..\..\..\tools\le501x\after_build.bat @L ..\..\..\.. dev\soc\arm_cm\le501x\bin\fw.hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --c99 -O2
  c include: ..\..\..\module\crc;..\..\..\module\debug;..\..\..\module\debug\RTT;..\..\..\module\static_buffer;..\..\..\module\tinyfs;..\..\..\module\tinycrypt\lib\include;..\..\..\module\ble;..\..\..\module\ble\prf;..\..\..\module\common;..\..\..\module\adpcm;..\..\..\peripheral\trng;..\..\..\peripheral\ecc;..\..\..\peripheral\crypt;..\..\..\peripheral\adc;..\..\..\peripheral\timer;..\..\..\peripheral\rtc;..\..\..\peripheral\spi;..\..\..\peripheral\api;..\..\..\peripheral\inc;..\..\..\soc\arm_cm;..\..\..\soc\arm_cm\cmsis;..\..\..\soc\arm_cm\le501x;..\..\..\soc\arm_cm\le501x\integration;..\..\..\soc;..\..\..;..;
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: ..\..\..\soc\arm_cm\le501x\compiler\armcc\link_script.txt
  link misc: --datacompressor=off
  group app
    ../: main.c
  group module
    ../../../module/debug/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
    ../../../module/adpcm/: adpcm.c
    ../../../module/common/: common.c
    ../../../module/crc/: crc16.c
    ../../../module/tinycrypt/lib/source/: ecc.c ecc_dsa.c ecc_platform_specific.c sha256.c utils.c
    ../../../module/static_buffer/: fifo.c linked_buffer.c
    ../../../module/debug/: log.c ls_dbg.c
    ../../../module/debug/arm_cm/armcc/: ls_dbg_asm.S
    ../../../module/tinyfs/: tinyfs.c tinyfs_nvm.c tinyfs_write_cache.c
  group peripheral
    ../../../peripheral/src/: calc_div.c dmac.c lscache.c lsiwdg.c lspdm.c lspdm_dma.c lsqspi.c spi_flash.c uart.c uart_dma.c
    ../../../peripheral/adc/: lsadc.c
    ../../../peripheral/crypt/: lscrypt.c
    ../../../peripheral/ecc/: lsecc.c
    ../../../peripheral/spi/: lsi2s.c lsspi.c
    ../../../peripheral/timer/: lstimer.c
    ../../../peripheral/trng/: lstrng.c
    ../../../peripheral/rtc/: rtc.c
  group soc
    ../../../soc/arm_cm/le501x/integration/: calc_acc.c dmac_msp.c io_config.c lscache_msp.c lsiwdg_msp.c lspdm_msp.c lsqspi_msp.c modem_rf_le501x.c rtc_param.c spi_msp.c uart_msp.c
    ../../../soc/arm_cm/le501x/: cpu.c platform.c sleep.c stack_var.c sys_stat.c
    ../../../soc/arm_cm/le501x/compiler/armcc/: delay_asm.S sleep_asm.S startup.S svcall_asm.S
    ../../../soc/: flash_svcall.c
    ../../../soc/arm_cm/le501x/bin/: libfw.o
    ../../../soc/arm_cm/: svcall.c swint_handler.c systick.c
