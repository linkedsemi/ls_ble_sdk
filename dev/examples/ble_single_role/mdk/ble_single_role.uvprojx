# Keil uVision project ble_single_role.uvprojx, settings and files
target ARMCM0 (ARM-ADS)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.3.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: ble_single_role
  AfterMake: ..\..\..\..\tools\disassemble.bat @L
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --c99 -O2 --wchar32
  c include: ..\..\..\..\inc;..\..\..\..\inc\cmsis;..\..\..\..\inc\prf;..\..\..\module\crc;..\..\..\module\debug;..\..\..\module\debug\RTT;..\..\..\module\static_buffer;..\..\..\module\tinyfs;..\..\..\module\tinycrypt\lib\include;..\..\..\peripheral\qspi_flash;..\..\..\peripheral\cache;..\..\..\peripheral\calc;..\..\..\peripheral\uart;..\..\..\peripheral\trng;..\..\..\peripheral\ecc;..\..\..\peripheral\crypt;..\..\..\peripheral\gpio;..\..\..\peripheral\iwdt;..\..\..\peripheral\adc;..\..\..\peripheral\timer;..\..\..\peripheral;..\..\..\soc\arm_cm;..\..\..\soc\arm_cm\le501x;..\..\..\soc\arm_cm\le501x\integration;..\..\..;..;
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: ..\..\..\soc\arm_cm\le501x\compiler\armcc\link_script.txt
  link misc: --datacompressor=off
  group Group1
    ../../../module/debug/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
    ../../../soc/arm_cm/le501x/integration/: calc_acc.c io_config.c lscache_param.c lsqspi_param.c modem_rf_le501x.c uart_param.c
    ../../../peripheral/calc/: calc_div.c
    ../../../module/common/: common.c
    ../../../soc/arm_cm/le501x/: cpu.c platform.c sleep.c stack_var.c sys_stat.c
    ../../../module/crc/: crc16.c
    ../../../soc/arm_cm/le501x/compiler/armcc/: delay_asm.s sleep_asm.s startup.s svcall_asm.s
    ../../../module/tinycrypt/lib/source/: ecc.c ecc_dsa.c ecc_platform_specific.c sha256.c utils.c
    ../../../soc/arm_cm/: flash_svcall.c svcall.c systick.c
    ../../../soc/arm_cm/le501x/bin/: libfw.o
    ../../../module/static_buffer/: linked_buffer.c
    ../../../module/debug/: log.c ls_dbg.c
    ../../../module/debug/asm/armcc/: ls_dbg_asm.s
    ../../../peripheral/adc/: lsadc.c
    ../../../peripheral/cache/: lscache.c
    ../../../peripheral/crypt/: lscrypt.c
    ../../../peripheral/ecc/: lsecc.c
    ../../../peripheral/gpio/: lsgpio.c
    ../../../peripheral/iwdt/: lsiwdt.c
    ../../../peripheral/qspi_flash/: lsqspi.c spi_flash.c
    ../../../peripheral/timer/: lstimer.c
    ../../../peripheral/trng/: lstrng.c
    ../: main.c
    ../../../module/tinyfs/: tinyfs.c tinyfs_nvm.c tinyfs_write_cache.c
    ../../../peripheral/uart/: uart.c
